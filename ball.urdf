Commit message: properly set initial ball config

File: ball.urdf (robot description, URDF)
Before this commit: robot ground, 1 links, 0 joints
Links:
- removed link ground
- added link ball, mass 1; collision sphere radius=0.03; visual sphere radius=0.03
